Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: 0001
Time: 2023-05-12T13:52:05
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20191106_1200(x64) - Exporter 20.2.1.1 - Alternate UI 20.2.1.1
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Fri May 12 13:52:05 2023 * Host: DESKTOP-JLKK7TQ * Database: C:\Users\vladb\AppData\Local\Temp\c1362efe-7afe-4e33-8565-67d0f9beb2a8\92107fcf-aaff-4adc-8446-7030d731fefa\ifc * Database version: 5507 * Database creation date: Fri May 12 13:52:04 2023 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Fri May 12 13:52:05 2023 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Fri May 12 13:52:05 2023 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, 0001
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 mm
Other - Category: Project Information; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: 0001; Project Status: Project Status

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Pset_ProductRequirements - Category: Project Information
Other - Category: Project Information; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: 0001; Project Status: Project Status

# IfcBuildingStorey: Level:8mm Head, Level 1
LongName: Level 1; Elevation: 0 mm
Other(Type) - Category: Levels; Family Name: Level
Identity Data(Type) - Type Name: 8mm Head
Pset_AirSideSystemInformation - Name: Level 1
Pset_ProductRequirements - Name: Level 1; Category: Levels
Constraints - Elevation: 0 mm
Dimensions - Computation Height: 0 mm
Identity Data - Building Story: yes; Name: Level 1; Structural: no
Other - Category: Levels; Family: Level: 8mm Head; Family and Type: Level: 8mm Head; Type: Level: 8mm Head; Type Id: Level: 8mm Head
Constraints(Type) - Elevation Base: Project Base Point
Graphics(Type) - Color: 0; Line Pattern: Centre; Line Weight: 1; Symbol: M_Level Head - Circle: M_Level Head - Circle; Symbol at End 1 Default: no; Symbol at End 2 Default: yes

# IfcFurnishingElement: Coffee Table, Vitra-Occasional_Tables-Noguchi_Coffee_Table_rfa:Coffee Table:376996
In: Level 1
Type - Material: Glass, Cast, Clear, Legs Black ash
Type - Constraints - Default Elevation: 0 mm
Type - General - Author: BIMStone; BIMObjectName: Vitra-Occasional_Tables-Noguchi_Coffee_Table_rfa; ManufacturerName: Vitra; ManufacturerURL: https://www.vitra.com/; NBSDescription: Tables; NBSReference: 45-35-86/327; ProductInformation: n/a; Revision: n/a; Uniclass2: Pr_40_50_21_14; Uniclass2015Description: Coffee tables; Uniclass2015Reference: Pr_40_50_21_14; Version: 1; VersionDate: 12/05/2023
Type - Identity Data - Cost: 0; Description: In creating his design for the Coffee Table, Isamu Noguchi translated the biomorphic aesthetic of his sculptural works into a piece of furniture with distinctive organic forms. Presumably for this reason, Noguchi regarded the table as his best furniture design. Two wooden leg elements, which are available in black ash, maple or walnut, are positioned at a right angle to provide a stable support for the heavy, sturdy glass top.; Designer: Isamu Noguchi, 1944; Manufacturer: Vitra; Model: Coffee Table; OmniClass Number: 23.40.20.14.17; OmniClass Title: Residential Tables and Cabinets; Type Name: Coffee Table; URL: https://www.vitra.com/en-hu/living/product/details/coffee-table
Type - Materials and Finishes - TableTopMaterial: Glass, Cast, Clear
Type - Other - Category: Furniture; AccessibilityPerformance: n/a; AssetType: Movable; Brand: Vitra; CodePerformance: n/a; Color: Various; Constituents: n/a; DurationUnit: Year; ExpectedLife: n/a; Family Name: Vitra-Occasional_Tables-Noguchi_Coffee_Table_rfa; Features: n/a; Finish: n/a; Grade: n/a; Material: Wood & glass; ModelNumber: n/a; ModelReference: n/a; Name: Noguchi_Coffee_Table_rfa; ReplacementCost: n/a; Shape: Sculptured; Size: 1276x920x400 mm; SustainabilityPerformance: n/a; WarrantyDescription: n/a; WarrantyDurationLabor: n/a; WarrantyDurationParts: n/a; WarrantyDurationUnit: Year; WarrantyGuarantorLabor: n/a; WarrantyGuarantorParts: n/a
Type - Pset_ElementShading - Color: Various
Type - Pset_ManufacturerTypeInformation - ModelReference: n/a; Manufacturer: Vitra
Type - Pset_ProductRequirements - Name: Noguchi_Coffee_Table_rfa; Category: Furniture
Type - Pset_QuantityTakeOff - Reference: Coffee Table
Pset_ManufacturerOccurrence - BarCode: n/a; SerialNumber: n/a
Constraints - Elevation from Level: 0 mm; Host: Level : Level 1; Level: Level: Level 1; Moves With Nearby Elements: no; Offset from Host: 0 mm
Dimensions - Area: 2.04687 m2; Volume: 0.467909 m3
Materials and Finishes - LegMaterial: Legs Black ash
Other - AssetIdentifier: n/a; Barcode: n/a; Family: Vitra-Occasional_Tables-Noguchi_Coffee_Table_rfa: Coffee Table; Family and Type: Vitra-Occasional_Tables-Noguchi_Coffee_Table_rfa: Coffee Table; InstallationDate: n/a; SerialNumber: n/a; TagNumber: n/a; Type: Vitra-Occasional_Tables-Noguchi_Coffee_Table_rfa: Coffee Table; Type Id: Vitra-Occasional_Tables-Noguchi_Coffee_Table_rfa: Coffee Table; WarrantyStartDate: n/a
Phasing - Phase Created: New Construction
